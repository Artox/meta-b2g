DESCRIPTION = "Firefox OS - Gecko Rendering Engine for LinuxGL "

COMPATIBLE_MACHINE = "qemux86"

SRCREV = "801ba75ac563"
MOZCONFIG_FILE = "mozconfig-b2g-linuxgl-rpi"

require b2g-linuxgl.inc
